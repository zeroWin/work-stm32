# Keil uVision project USART.uvproj, settings and files
target USART-test (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART-test +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: ..\FWlib\src;..\CMSIS;..\USER;..\FWlib\inc;..\HARDWARE\OLED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\SDcard;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\BLUETOOTH;..\HARDWARE\CC2530
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../CMSIS/startup/: startup_stm32l1xx_md.s
  group USER
    ./: main.c stm32l1xx_it.c
  group FWlib
    ../FWlib/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c misc.c stm32l1xx_exti.c stm32l1xx_rtc.c stm32l1xx_pwr.c stm32l1xx_spi.c stm32l1xx_dma.c stm32l1xx_tim.c
  group CMSIS
    ../CMSIS/: system_stm32l1xx.c core_cm3.c
  group HARDWARE
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/RTC/: RTC.c
    ../HARDWARE/SDcard/: SDcard.c SPI.c
    ../HARDWARE/BLUETOOTH/: UART1.c
    ../HARDWARE/CC2530/: UART2.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
